<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IARproject.ewp</path>
  </project>
  <project>
    <path>C:\Users\Public\Desktop\TestPrograms\IAR\Kit Evaluation - Test code\lab3_cokfi.ewp</path>
  </project>
  <batchBuild/>
</workspace>


